# Keil uVision project VVK-S5.uvprojx, settings and files
target POC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TP79_BOOT +hex
  AfterMake: C:\Keil_v5_525\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/@L.bin ./Objects/@L.axf
  AfterMake: find   "Total R"    ./Listing/@L.map
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\inc;..\Libraries;..\Src\app;..\Src\drv;..\Src\usr;..\Src\utils
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Usr
    ../Src/usr/: stm32f10x_it.c
    ../Libraries/: startup_stm32f10x_hd.s
  group Drv
    ../Src/drv/: uart.c flash.c flash.h GT21L16S2Y.C GT21L16S2Y.H nv3021.c nv3021.h poc.c poc.h
    ../Src/app/: my_string.c my_string.h device.c device.h
  group Lib
    ../Libraries/: core_cm3.c system_stm32f10x.c
    ../Libraries/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c
    ../Src/usr/: main.c
